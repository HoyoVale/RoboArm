# Keil uVision project STC15_RobotArm_Controller.uvproj, settings and files
target IAP15_RobotArm_Controller (MCS-51)
  device: 8XC52 Generic 8051
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(22118400) MODP2
  output: STC15_RobotArm_Controller +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\
  group Source
    ./: main.c iap15w4k61s4.h
  group Documentation
    ./: README.md
